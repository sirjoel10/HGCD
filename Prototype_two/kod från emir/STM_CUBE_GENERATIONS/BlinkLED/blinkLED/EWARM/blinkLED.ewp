# IAR project blinkLED.ewp, settings and files
configuration blinkLED (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: blinkLED.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ./: 
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash.c stm32l4xx_hal_rcc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_uart.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_dma.c
  group Application
    ./: 
  group Application/EWARM
    C:/Users/Simon Lindell/Desktop/Development/NEW/STM_CUBE_GENERATIONS/BlinkLED/blinkLED//EWARM/: startup_stm32l476xx.s
  group Application/User
    ./: 
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c
